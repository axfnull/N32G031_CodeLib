# Keil uVision project CompOut.uvprojx, settings and files
target N32G031 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32G031C8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CompOut_Project
  AfterMake: fromelf --bin --output=.\bin\CompOut_Project.bin .\Objects\CompOut_Project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G031, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g031_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g031.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g031.c
  group FWLB
    ../../../../../../firmware/n32g031_std_periph_driver/src/: misc.c n32g031_comp.c n32g031_dbg.c n32g031_exti.c n32g031_gpio.c n32g031_rcc.c n32g031_tim.c n32g031_usart.c n32g031_adc.c n32g031_crc.c n32g031_dma.c n32g031_flash.c n32g031_i2c.c n32g031_iwdg.c n32g031_lptim.c n32g031_lpuart.c n32g031_opamp.c n32g031_pwr.c n32g031_rtc.c n32g031_spi.c n32g031_wwdg.c
  group USER
    ../src/: main.c n32g031_it.c
  group DOC
    ../: readme.txt
